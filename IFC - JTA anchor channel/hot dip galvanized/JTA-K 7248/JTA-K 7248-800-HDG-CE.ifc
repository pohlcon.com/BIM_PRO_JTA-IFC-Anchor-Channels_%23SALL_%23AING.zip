Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
File name: Projektnummer
Time: 2017-11-03T15:29:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 03 15:29:15 2017 * Host: JORNBBLN-012 * Database: C:\Users\DENNIS~1.NEU\AppData\Local\Temp\{7F81D438-7A17-4FE0-A266-412F5DC4101B}\ifc * Database version: 5507 * Database creation date: Fri Nov 03 15:29:14 2017 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Nov 03 15:29:14 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 03 15:29:14 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 759999; RefLongitude: 13, 23, 59, 999999; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - Reference: Projektinformationen; NumberOfStoreys: 1

# IfcBuildingStorey, Ebene -1
LongName: Ebene -1; Elevation: -3 m

# IfcFastener: JTA-W L=800 mm, JTA-K JORDAHL® AnchorChannels:JTA-W L=800 mm:388280
In: Ebene -1
Type - PredefinedType: GLUE; Material: Steel
Pset_ManufacturerTypeInformation - Manufacturer: JORDAHL® GmbH
