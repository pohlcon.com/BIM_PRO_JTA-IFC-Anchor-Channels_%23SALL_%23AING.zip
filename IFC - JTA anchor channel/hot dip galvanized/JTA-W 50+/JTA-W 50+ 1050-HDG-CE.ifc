Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
File name: Projektnummer
Time: 2017-11-03T13:05:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 03 13:05:04 2017 * Host: JORNBBLN-012 * Database: C:\Users\DENNIS~1.NEU\AppData\Local\Temp\{95F1DA96-0CCA-4958-A11E-7697E46BAE4D}\ifc * Database version: 5507 * Database creation date: Fri Nov 03 13:05:02 2017 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Nov 03 13:05:03 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 03 13:05:03 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 759999; RefLongitude: 13, 23, 59, 999999; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - Reference: Projektinformationen; NumberOfStoreys: 1

# IfcBuildingStorey, Ebene -1
LongName: Ebene -1; Elevation: -3 m

# IfcFastener: JTA-W L=1050 mm, JTA-W JORDAHL® AnchorChannels:JTA-W L=1050 mm:380234
In: Ebene -1
Type - PredefinedType: GLUE; Material: Steel
Pset_ManufacturerTypeInformation - Manufacturer: JORDAHL® GmbH
